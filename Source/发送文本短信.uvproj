# Keil uVision project 发送文本短信.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC12C5A60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: 发送文本短信 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\GSM;.\Ultrasonic;.\XY-V17B;.\DS18B20;.\uart;.\delay;.\LED;.\BH1750;.\DHT11
  group Source Group 1
    ./: main.c
    ./GSM/: GSM.c
    ./Ultrasonic/: Ultrasonic.c
    ./XY-V17B/: XY-V17B.c
    ./DS18B20/: DS18B20.c
    ./uart/: uart.c
    ./delay/: delay.c
    ./LED/: LED.c
    ./BH1750/: BH1750.c
    ./DHT11/: DHT11.C
